v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {2bit_comps_2x.sym} 30 -10 0 0 {name=x1}
