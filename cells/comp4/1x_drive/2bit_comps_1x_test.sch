v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {2bit_comps_1x.sym} 30 0 0 0 {name=x1}
