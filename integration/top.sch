v {xschem version=3.4.7 file_version=1.2
* Copyright 2022 GlobalFoundries PDK Authors
*
* Licensed under the Apache License, Version 2.0 (the "License");
* you may not use this file except in compliance with the License.
* You may obtain a copy of the License at
*
*     https://www.apache.org/licenses/LICENSE-2.0
*
* Unless required by applicable law or agreed to in writing, software
* distributed under the License is distributed on an "AS IS" BASIS,
* WITHOUT WARRANTIES OR CONDITIONS OF ANY KIND, either express or implied.
* See the License for the specific language governing permissions and
* limitations under the License.

}
G {}
K {}
V {}
S {}
E {}
T {Symbelleuit} 210 1140 0 0 1 1 {}
T {Symbelleuit} 1740 1160 0 0 1 1 {}
T {Nawiatsob} 4850 1080 0 0 1 1 {}
T {SILICON} 530 1790 0 0 1 1 {}
T {SILICON} 2140 1800 0 0 1 1 {}
T {SILICON} 2160 2680 0 0 1 1 {}
T {SILICON} 550 2660 0 0 1 1 {}
T {SILICON} 540 3660 0 0 1 1 {}
T {SILICON} 2200 3660 0 0 1 1 {}
N 720 680 820 680 {lab=#net1}
N 820 680 820 1070 {lab=#net1}
N 820 1070 950 1070 {lab=#net1}
N 720 660 890 660 {lab=#net2}
N 890 660 890 780 {lab=#net2}
N 890 780 950 780 {lab=#net2}
N 720 500 720 640 {lab=#net3}
N 720 500 950 500 {lab=#net3}
N 490 650 620 650 {lab=#net4}
N 490 470 490 630 {lab=#net4}
N 490 630 490 650 {lab=#net4}
N 440 770 560 770 {lab=#net5}
N 560 680 560 770 {lab=#net5}
N 560 680 620 680 {lab=#net5}
N 440 470 490 470 {lab=#net4}
N 1210 740 1300 740 {lab=E}
N 1210 460 1290 460 {lab=L}
N 1210 1030 1310 1030 {lab=G}
N 130 530 180 530 {lab=A}
N 130 830 180 830 {lab=B}
N 1090 600 1130 600 {lab=VDD}
N 1090 580 1130 580 {lab=VSS}
N 1090 320 1130 320 {lab=VDD}
N 1090 860 1130 860 {lab=VSS}
N 1090 890 1130 890 {lab=VDD}
N 260 950 300 950 {lab=VSS}
N 780 110 820 110 {lab=VDD}
N 260 390 300 390 {lab=VDD}
N 260 650 300 650 {lab=VSS}
N 260 690 300 690 {lab=VDD}
N 510 260 550 260 {lab=VSS}
N 1090 1150 1130 1150 {lab=VSS}
N 800 50 800 110 {lab=VDD}
N 800 50 840 50 {lab=VDD}
N 530 260 530 300 {lab=VSS}
N 530 300 540 300 {lab=VSS}
N 780 270 780 290 {lab=VSS}
N 670 740 670 760 {lab=VSS}
N 280 950 280 970 {lab=VSS}
N 280 650 280 660 {lab=VSS}
N 240 660 280 660 {lab=VSS}
N 1260 200 1260 230 {lab=VSS}
N 1260 100 1260 140 {lab=VDD}
N 2280 660 2380 660 {lab=#net6}
N 2380 660 2380 1050 {lab=#net6}
N 2380 1050 2510 1050 {lab=#net6}
N 2280 640 2450 640 {lab=#net7}
N 2450 640 2450 760 {lab=#net7}
N 2450 760 2510 760 {lab=#net7}
N 2280 480 2280 620 {lab=#net8}
N 2280 480 2510 480 {lab=#net8}
N 2050 630 2180 630 {lab=#net9}
N 2050 450 2050 610 {lab=#net9}
N 2050 610 2050 630 {lab=#net9}
N 2000 750 2120 750 {lab=#net10}
N 2120 660 2120 750 {lab=#net10}
N 2120 660 2180 660 {lab=#net10}
N 2000 450 2050 450 {lab=#net9}
N 2770 720 2860 720 {lab=E}
N 2770 440 2850 440 {lab=L}
N 2770 1010 2870 1010 {lab=G}
N 1690 510 1740 510 {lab=A}
N 1690 810 1740 810 {lab=B}
N 2650 580 2690 580 {lab=VDD}
N 2650 560 2690 560 {lab=VSS}
N 2650 300 2690 300 {lab=VDD}
N 2650 840 2690 840 {lab=VSS}
N 2650 870 2690 870 {lab=VDD}
N 1820 930 1860 930 {lab=VSS}
N 1820 370 1860 370 {lab=VDD}
N 1820 630 1860 630 {lab=VSS}
N 1820 670 1860 670 {lab=VDD}
N 2650 1130 2690 1130 {lab=VSS}
N 2230 720 2230 740 {lab=VSS}
N 1840 930 1840 950 {lab=VSS}
N 1840 630 1840 640 {lab=VSS}
N 1800 640 1840 640 {lab=VSS}
N 4410 220 4530 220 {lab=#net11}
N 4100 280 4150 280 {lab=B}
N 4230 400 4270 400 {lab=VSS}
N 4230 140 4270 140 {lab=VDD}
N 4250 400 4250 420 {lab=VSS}
N 4410 570 4530 570 {lab=#net12}
N 4100 630 4150 630 {lab=B}
N 4230 750 4270 750 {lab=VSS}
N 4230 490 4270 490 {lab=VDD}
N 4250 750 4250 770 {lab=VSS}
N 4410 930 4530 930 {lab=#net13}
N 4100 990 4150 990 {lab=B}
N 4230 1110 4270 1110 {lab=VSS}
N 4230 850 4270 850 {lab=VDD}
N 4250 1110 4250 1130 {lab=VSS}
N 4410 -120 4530 -120 {lab=#net14}
N 4100 -60 4150 -60 {lab=B}
N 4230 60 4270 60 {lab=VSS}
N 4230 -200 4270 -200 {lab=VDD}
N 4250 60 4250 80 {lab=VSS}
N 4410 1270 4530 1270 {lab=#net15}
N 4100 1330 4150 1330 {lab=B}
N 4230 1450 4270 1450 {lab=VSS}
N 4230 1190 4270 1190 {lab=VDD}
N 4250 1450 4250 1470 {lab=VSS}
N 4410 1590 4530 1590 {lab=#net16}
N 4100 1650 4150 1650 {lab=B}
N 4230 1770 4270 1770 {lab=VSS}
N 4230 1510 4270 1510 {lab=VDD}
N 4250 1770 4250 1790 {lab=VSS}
N 4530 -120 4740 -120 {lab=#net14}
N 4740 -120 4740 740 {lab=#net14}
N 4740 740 4760 740 {lab=#net14}
N 4530 1590 4740 1590 {lab=#net16}
N 4740 840 4740 1590 {lab=#net16}
N 4740 840 4760 840 {lab=#net16}
N 4530 220 4720 220 {lab=#net11}
N 4720 220 4720 760 {lab=#net11}
N 4720 760 4760 760 {lab=#net11}
N 4530 1270 4720 1270 {lab=#net15}
N 4720 820 4720 1270 {lab=#net15}
N 4720 820 4760 820 {lab=#net15}
N 4530 570 4700 570 {lab=#net12}
N 4700 570 4700 780 {lab=#net12}
N 4700 780 4760 780 {lab=#net12}
N 4530 930 4700 930 {lab=#net13}
N 4700 800 4700 930 {lab=#net13}
N 4700 800 4760 800 {lab=#net13}
N 5570 810 5650 810 {lab=L}
N 5450 930 5490 930 {lab=VSS}
N 5450 670 5490 670 {lab=VDD}
N 5060 780 5240 780 {lab=#net17}
N 5240 780 5240 850 {lab=#net17}
N 5240 850 5310 850 {lab=#net17}
N 320 1360 440 1360 {lab=#net18}
N 440 1360 440 1690 {lab=#net18}
N 440 1690 500 1690 {lab=#net18}
N 320 1650 400 1650 {lab=#net19}
N 400 1650 400 1710 {lab=#net19}
N 400 1710 500 1710 {lab=#net19}
N 320 1940 450 1940 {lab=#net20}
N 450 1730 450 1940 {lab=#net20}
N 450 1730 500 1730 {lab=#net20}
N 140 1280 180 1280 {lab=#net21}
N 140 1540 180 1540 {lab=#net22}
N 140 1570 180 1570 {lab=#net23}
N 140 1830 180 1830 {lab=#net24}
N 140 1860 180 1860 {lab=#net25}
N 140 2120 180 2120 {lab=#net26}
N 800 1710 940 1710 {lab=#net27}
N 1080 1530 1120 1530 {lab=#net28}
N 1080 1790 1120 1790 {lab=#net29}
N 1910 1360 2030 1360 {lab=#net18}
N 2030 1360 2030 1690 {lab=#net18}
N 2030 1690 2090 1690 {lab=#net18}
N 1910 1650 1990 1650 {lab=#net19}
N 1990 1650 1990 1710 {lab=#net19}
N 1990 1710 2090 1710 {lab=#net19}
N 1910 1940 2040 1940 {lab=#net20}
N 2040 1730 2040 1940 {lab=#net20}
N 2040 1730 2090 1730 {lab=#net20}
N 1730 1280 1770 1280 {lab=#net21}
N 1730 1540 1770 1540 {lab=#net22}
N 1730 1570 1770 1570 {lab=#net23}
N 1730 1830 1770 1830 {lab=#net24}
N 1730 1860 1770 1860 {lab=#net25}
N 1730 2120 1770 2120 {lab=#net26}
N 2390 1710 2530 1710 {lab=#net27}
N 2670 1530 2710 1530 {lab=#net28}
N 2670 1790 2710 1790 {lab=#net29}
N 320 2250 440 2250 {lab=#net18}
N 440 2250 440 2580 {lab=#net18}
N 440 2580 500 2580 {lab=#net18}
N 320 2540 400 2540 {lab=#net19}
N 400 2540 400 2600 {lab=#net19}
N 400 2600 500 2600 {lab=#net19}
N 320 2830 450 2830 {lab=#net20}
N 450 2620 450 2830 {lab=#net20}
N 450 2620 500 2620 {lab=#net20}
N 140 2170 180 2170 {lab=#net21}
N 140 2430 180 2430 {lab=#net22}
N 140 2460 180 2460 {lab=#net23}
N 140 2720 180 2720 {lab=#net24}
N 140 2750 180 2750 {lab=#net25}
N 140 3010 180 3010 {lab=#net26}
N 800 2600 940 2600 {lab=#net27}
N 1080 2420 1120 2420 {lab=#net28}
N 1080 2680 1120 2680 {lab=#net29}
N 1940 2250 2060 2250 {lab=#net18}
N 2060 2250 2060 2580 {lab=#net18}
N 2060 2580 2120 2580 {lab=#net18}
N 1940 2540 2020 2540 {lab=#net19}
N 2020 2540 2020 2600 {lab=#net19}
N 2020 2600 2120 2600 {lab=#net19}
N 1940 2830 2070 2830 {lab=#net20}
N 2070 2620 2070 2830 {lab=#net20}
N 2070 2620 2120 2620 {lab=#net20}
N 1760 2170 1800 2170 {lab=#net21}
N 1760 2430 1800 2430 {lab=#net22}
N 1760 2460 1800 2460 {lab=#net23}
N 1760 2720 1800 2720 {lab=#net24}
N 1760 2750 1800 2750 {lab=#net25}
N 1760 3010 1800 3010 {lab=#net26}
N 2420 2600 2560 2600 {lab=#net27}
N 2700 2420 2740 2420 {lab=#net28}
N 2700 2680 2740 2680 {lab=#net29}
N 1970 3260 2090 3260 {lab=#net18}
N 2090 3260 2090 3590 {lab=#net18}
N 2090 3590 2150 3590 {lab=#net18}
N 1970 3550 2050 3550 {lab=#net19}
N 2050 3550 2050 3610 {lab=#net19}
N 2050 3610 2150 3610 {lab=#net19}
N 1970 3840 2100 3840 {lab=#net20}
N 2100 3630 2100 3840 {lab=#net20}
N 2100 3630 2150 3630 {lab=#net20}
N 1790 3180 1830 3180 {lab=#net21}
N 1790 3440 1830 3440 {lab=#net22}
N 1790 3470 1830 3470 {lab=#net23}
N 1790 3730 1830 3730 {lab=#net24}
N 1790 3760 1830 3760 {lab=#net25}
N 1790 4020 1830 4020 {lab=#net26}
N 2450 3610 2590 3610 {lab=#net27}
N 2730 3430 2770 3430 {lab=#net28}
N 2730 3690 2770 3690 {lab=#net29}
N 320 3260 440 3260 {lab=#net18}
N 440 3260 440 3590 {lab=#net18}
N 440 3590 500 3590 {lab=#net18}
N 320 3550 400 3550 {lab=#net19}
N 400 3550 400 3610 {lab=#net19}
N 400 3610 500 3610 {lab=#net19}
N 320 3840 450 3840 {lab=#net20}
N 450 3630 450 3840 {lab=#net20}
N 450 3630 500 3630 {lab=#net20}
N 140 3180 180 3180 {lab=#net21}
N 140 3440 180 3440 {lab=#net22}
N 140 3470 180 3470 {lab=#net23}
N 140 3730 180 3730 {lab=#net24}
N 140 3760 180 3760 {lab=#net25}
N 140 4020 180 4020 {lab=#net26}
N 800 3610 940 3610 {lab=#net27}
N 1080 3430 1120 3430 {lab=#net28}
N 1080 3690 1120 3690 {lab=#net29}
C {devices/title.sym} 160 -30 0 0 {name=l5 author="Integration Padframe"}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 180 950 0 0 {name=IO1
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_dvdd.sym} 430 260 0 0 {name=IO2
model=gf180mcu_fd_io__dvdd
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_dvss.sym} 700 270 0 0 {name=IO3
model=gf180mcu_fd_io__dvss
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 180 650 0 0 {name=IO4
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1210 580 0 1 {name=IO5
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1210 860 0 1 {name=IO6
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1210 1150 0 1 {name=IO7
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/ipin.sym} 130 530 0 0 {name=p1 lab=A}
C {devices/opin.sym} 1290 460 0 0 {name=p2 lab=L}
C {devices/iopin.sym} 540 300 0 0 {name=p3 lab=VSS}
C {devices/ipin.sym} 130 830 0 0 {name=p4 lab=B}
C {devices/opin.sym} 1300 740 0 0 {name=p5 lab=E}
C {devices/opin.sym} 1310 1030 0 0 {name=p6 lab=G}
C {devices/iopin.sym} 840 50 0 0 {name=p7 lab=VDD}
C {cells/D17_Symbelleuit/gf180mcu_gp9t3v3__comp2_2.sym} 670 670 0 0 {name=x1}
C {devices/lab_pin.sym} 530 290 0 0 {name=p8 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 780 290 0 0 {name=p9 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 670 760 0 0 {name=p10 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 280 970 0 0 {name=p11 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 240 660 0 0 {name=p12 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1090 580 0 0 {name=p13 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1090 1150 0 0 {name=p14 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1090 860 0 0 {name=p15 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 510 100 0 0 {name=p16 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 800 90 0 0 {name=p17 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 260 390 0 0 {name=p18 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 260 690 0 0 {name=p19 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 1090 320 0 0 {name=p20 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 1090 600 0 0 {name=p21 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 1090 890 0 0 {name=p22 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 670 590 0 0 {name=p23 sig_type=std_logic lab=VDD

}
C {tieH_L.sym} 1110 170 0 0 {name=x2}
C {devices/lab_pin.sym} 1260 100 0 0 {name=p24 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 1260 230 0 0 {name=p25 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1260 160 0 1 {name=p26 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1260 180 0 1 {name=p27 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 440 430 0 1 {name=p28 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 440 730 0 1 {name=p29 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 950 540 0 0 {name=p30 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1260 160 0 1 {name=p31 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 950 820 0 0 {name=p32 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 950 1110 0 0 {name=p33 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 950 1030 0 0 {name=p34 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 950 1050 0 0 {name=p35 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 950 740 0 0 {name=p36 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 950 760 0 0 {name=p37 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 950 460 0 0 {name=p38 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 950 480 0 0 {name=p39 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 440 910 0 1 {name=p44 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 440 610 0 1 {name=p45 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 950 930 0 0 {name=p46 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 950 640 0 0 {name=p47 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 950 360 0 0 {name=p48 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 950 800 0 0 {name=p49 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 950 1090 0 0 {name=p50 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 950 520 0 0 {name=p51 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 440 510 0 1 {name=p40 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 440 490 0 1 {name=p41 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 440 450 0 1 {name=p42 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 440 790 0 1 {name=p43 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 440 810 0 1 {name=p52 sig_type=std_logic lab=H}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1740 930 0 0 {name=IO8
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1740 630 0 0 {name=IO9
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 2770 560 0 1 {name=IO10
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 2770 840 0 1 {name=IO11
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 2770 1130 0 1 {name=IO12
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/ipin.sym} 1690 510 0 0 {name=p53 lab=A}
C {devices/opin.sym} 2850 440 0 0 {name=p54 lab=L}
C {devices/ipin.sym} 1690 810 0 0 {name=p55 lab=B}
C {devices/opin.sym} 2860 720 0 0 {name=p56 lab=E}
C {devices/opin.sym} 2870 1010 0 0 {name=p57 lab=G}
C {devices/lab_pin.sym} 2230 740 0 0 {name=p58 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1840 950 0 0 {name=p59 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1800 640 0 0 {name=p60 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2650 560 0 0 {name=p61 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2650 1130 0 0 {name=p62 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2650 840 0 0 {name=p63 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1820 370 0 0 {name=p64 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 1820 670 0 0 {name=p65 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 2650 300 0 0 {name=p66 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 2650 580 0 0 {name=p67 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 2650 870 0 0 {name=p68 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 2230 570 0 0 {name=p69 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 2000 410 0 1 {name=p70 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 2000 710 0 1 {name=p71 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 2510 520 0 0 {name=p72 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 2510 800 0 0 {name=p73 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 2510 1090 0 0 {name=p74 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 2510 1010 0 0 {name=p75 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 2510 1030 0 0 {name=p76 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2510 720 0 0 {name=p77 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 2510 740 0 0 {name=p78 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2510 440 0 0 {name=p79 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 2510 460 0 0 {name=p80 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2000 890 0 1 {name=p81 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2000 590 0 1 {name=p82 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2510 910 0 0 {name=p83 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2510 620 0 0 {name=p84 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2510 340 0 0 {name=p85 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2510 780 0 0 {name=p86 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2510 1070 0 0 {name=p87 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2510 500 0 0 {name=p88 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2000 490 0 1 {name=p89 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 2000 470 0 1 {name=p90 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2000 430 0 1 {name=p91 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2000 770 0 1 {name=p92 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2000 790 0 1 {name=p93 sig_type=std_logic lab=H}
C {cells/D17_Symbelleuit/gf180mcu_gp9t3v3__comp2_1.sym} 2230 640 0 0 {name=x3}
C {cells/D15_SILICON/gf180mcu_osu_sc_gp12t3v3__and3_1.sym} 650 1710 0 0 {name=x4}
C {cells/D15_SILICON/gf180mcu_osu_sc_gp12t3v3__nand3_1.sym} 2240 1710 0 0 {name=x5}
C {cells/D15_SILICON/gf180mcu_osu_sc_gp12t3v3__nor3_1.sym} 650 2600 0 0 {name=x6}
C {cells/D15_SILICON/gf180mcu_osu_sc_gp9t3v3__and3_2.sym} 2270 2600 0 0 {name=x7}
C {cells/D15_SILICON/gf180mcu_osu_sc_gp9t3v3__or3_1.sym} 650 3610 0 0 {name=x8}
C {cells/D15_SILICON/gf180mcu_osu_sc_gp9t3v3_nor3_1.sym} 2300 3610 0 0 {name=x9}
C {cells/D9_Nawiatsob/gf180mcu_osu_sc_gp9t3v3__mux4_1.sym} 4910 790 0 0 {name=x10}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 4150 400 0 0 {name=IO13
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/ipin.sym} 4100 280 0 0 {name=p94 lab=B}
C {devices/lab_pin.sym} 4250 420 0 0 {name=p95 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4230 140 0 0 {name=p96 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 4410 180 0 1 {name=p97 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 4410 360 0 1 {name=p98 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 4410 240 0 1 {name=p99 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 4410 260 0 1 {name=p100 sig_type=std_logic lab=H}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 4150 750 0 0 {name=IO14
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/ipin.sym} 4100 630 0 0 {name=p101 lab=B}
C {devices/lab_pin.sym} 4250 770 0 0 {name=p102 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4230 490 0 0 {name=p103 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 4410 530 0 1 {name=p104 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 4410 710 0 1 {name=p105 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 4410 590 0 1 {name=p106 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 4410 610 0 1 {name=p107 sig_type=std_logic lab=H}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 4150 1110 0 0 {name=IO15
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/ipin.sym} 4100 990 0 0 {name=p108 lab=B}
C {devices/lab_pin.sym} 4250 1130 0 0 {name=p109 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4230 850 0 0 {name=p110 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 4410 890 0 1 {name=p111 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 4410 1070 0 1 {name=p112 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 4410 950 0 1 {name=p113 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 4410 970 0 1 {name=p114 sig_type=std_logic lab=H}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 4150 60 0 0 {name=IO16
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/ipin.sym} 4100 -60 0 0 {name=p115 lab=B}
C {devices/lab_pin.sym} 4250 80 0 0 {name=p116 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4230 -200 0 0 {name=p117 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 4410 -160 0 1 {name=p118 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 4410 20 0 1 {name=p119 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 4410 -100 0 1 {name=p120 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 4410 -80 0 1 {name=p121 sig_type=std_logic lab=H}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 4150 1450 0 0 {name=IO17
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/ipin.sym} 4100 1330 0 0 {name=p122 lab=B}
C {devices/lab_pin.sym} 4250 1470 0 0 {name=p123 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4230 1190 0 0 {name=p124 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 4410 1230 0 1 {name=p125 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 4410 1410 0 1 {name=p126 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 4410 1290 0 1 {name=p127 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 4410 1310 0 1 {name=p128 sig_type=std_logic lab=H}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 4150 1770 0 0 {name=IO18
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/ipin.sym} 4100 1650 0 0 {name=p129 lab=B}
C {devices/lab_pin.sym} 4250 1790 0 0 {name=p130 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4230 1510 0 0 {name=p131 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 4410 1550 0 1 {name=p132 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 4410 1730 0 1 {name=p133 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 4410 1610 0 1 {name=p134 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 4410 1630 0 1 {name=p135 sig_type=std_logic lab=H}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 5570 930 0 1 {name=IO19
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/opin.sym} 5650 810 0 0 {name=p136 lab=L}
C {devices/lab_pin.sym} 5450 930 0 0 {name=p137 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5450 670 0 0 {name=p138 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 5310 890 0 0 {name=p139 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 5310 810 0 0 {name=p140 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 5310 830 0 0 {name=p141 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 5310 710 0 0 {name=p142 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 5310 870 0 0 {name=p143 sig_type=std_logic lab=L}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 60 2120 0 0 {name=IO20
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 60 1830 0 0 {name=IO21
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 60 1540 0 0 {name=IO22
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/lab_pin.sym} 320 1320 0 1 {name=p144 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 320 1610 0 1 {name=p145 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 320 1900 0 1 {name=p146 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 320 1400 0 1 {name=p147 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 320 1690 0 1 {name=p148 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 320 1980 0 1 {name=p149 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 320 1500 0 1 {name=p150 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 320 2080 0 1 {name=p151 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 320 1790 0 1 {name=p152 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 320 1670 0 1 {name=p153 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 320 1960 0 1 {name=p154 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 320 1380 0 1 {name=p155 sig_type=std_logic lab=L}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1200 1790 0 1 {name=IO23
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/lab_pin.sym} 940 1750 0 0 {name=p156 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 940 1670 0 0 {name=p157 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 940 1690 0 0 {name=p158 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 940 1730 0 0 {name=p159 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 940 1570 0 0 {name=p160 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 140 1540 0 0 {name=p161 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 140 1280 0 0 {name=p162 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 140 1830 0 0 {name=p163 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 140 2120 0 0 {name=p164 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1080 1790 0 0 {name=p165 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 140 1570 0 0 {name=p166 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 140 1860 0 0 {name=p167 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 1080 1530 0 0 {name=p168 sig_type=std_logic lab=VDD

}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1650 2120 0 0 {name=IO24
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1650 1830 0 0 {name=IO25
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1650 1540 0 0 {name=IO26
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/lab_pin.sym} 1910 1320 0 1 {name=p169 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1910 1610 0 1 {name=p170 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1910 1900 0 1 {name=p171 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1910 1400 0 1 {name=p172 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1910 1690 0 1 {name=p173 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1910 1980 0 1 {name=p174 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1910 1500 0 1 {name=p175 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 1910 2080 0 1 {name=p176 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 1910 1790 0 1 {name=p177 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 1910 1670 0 1 {name=p178 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 1910 1960 0 1 {name=p179 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 1910 1380 0 1 {name=p180 sig_type=std_logic lab=L}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 2790 1790 0 1 {name=IO27
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/lab_pin.sym} 2530 1750 0 0 {name=p181 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 2530 1670 0 0 {name=p182 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 2530 1690 0 0 {name=p183 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2530 1730 0 0 {name=p184 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2530 1570 0 0 {name=p185 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 1730 1540 0 0 {name=p186 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1730 1280 0 0 {name=p187 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 1730 1830 0 0 {name=p188 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1730 2120 0 0 {name=p189 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2670 1790 0 0 {name=p190 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1730 1570 0 0 {name=p191 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 1730 1860 0 0 {name=p192 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 2670 1530 0 0 {name=p193 sig_type=std_logic lab=VDD

}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 60 3010 0 0 {name=IO28
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 60 2720 0 0 {name=IO29
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 60 2430 0 0 {name=IO30
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/lab_pin.sym} 320 2210 0 1 {name=p194 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 320 2500 0 1 {name=p195 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 320 2790 0 1 {name=p196 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 320 2290 0 1 {name=p197 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 320 2580 0 1 {name=p198 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 320 2870 0 1 {name=p199 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 320 2390 0 1 {name=p200 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 320 2970 0 1 {name=p201 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 320 2680 0 1 {name=p202 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 320 2560 0 1 {name=p203 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 320 2850 0 1 {name=p204 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 320 2270 0 1 {name=p205 sig_type=std_logic lab=L}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1200 2680 0 1 {name=IO31
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/lab_pin.sym} 940 2640 0 0 {name=p206 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 940 2560 0 0 {name=p207 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 940 2580 0 0 {name=p208 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 940 2620 0 0 {name=p209 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 940 2460 0 0 {name=p210 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 140 2430 0 0 {name=p211 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 140 2170 0 0 {name=p212 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 140 2720 0 0 {name=p213 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 140 3010 0 0 {name=p214 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1080 2680 0 0 {name=p215 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 140 2460 0 0 {name=p216 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 140 2750 0 0 {name=p217 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 1080 2420 0 0 {name=p218 sig_type=std_logic lab=VDD

}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1680 3010 0 0 {name=IO32
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1680 2720 0 0 {name=IO33
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1680 2430 0 0 {name=IO34
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/lab_pin.sym} 1940 2210 0 1 {name=p219 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1940 2500 0 1 {name=p220 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1940 2790 0 1 {name=p221 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1940 2290 0 1 {name=p222 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1940 2580 0 1 {name=p223 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1940 2870 0 1 {name=p224 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1940 2390 0 1 {name=p225 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 1940 2970 0 1 {name=p226 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 1940 2680 0 1 {name=p227 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 1940 2560 0 1 {name=p228 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 1940 2850 0 1 {name=p229 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 1940 2270 0 1 {name=p230 sig_type=std_logic lab=L}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 2820 2680 0 1 {name=IO35
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/lab_pin.sym} 2560 2640 0 0 {name=p231 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 2560 2560 0 0 {name=p232 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 2560 2580 0 0 {name=p233 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2560 2620 0 0 {name=p234 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2560 2460 0 0 {name=p235 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 1760 2430 0 0 {name=p236 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1760 2170 0 0 {name=p237 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 1760 2720 0 0 {name=p238 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1760 3010 0 0 {name=p239 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2700 2680 0 0 {name=p240 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1760 2460 0 0 {name=p241 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 1760 2750 0 0 {name=p242 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 2700 2420 0 0 {name=p243 sig_type=std_logic lab=VDD

}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1710 4020 0 0 {name=IO36
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1710 3730 0 0 {name=IO37
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1710 3440 0 0 {name=IO38
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/lab_pin.sym} 1970 3220 0 1 {name=p244 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1970 3510 0 1 {name=p245 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1970 3800 0 1 {name=p246 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1970 3300 0 1 {name=p247 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1970 3590 0 1 {name=p248 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1970 3880 0 1 {name=p249 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 1970 3400 0 1 {name=p250 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 1970 3980 0 1 {name=p251 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 1970 3690 0 1 {name=p252 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 1970 3570 0 1 {name=p253 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 1970 3860 0 1 {name=p254 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 1970 3280 0 1 {name=p255 sig_type=std_logic lab=L}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 2850 3690 0 1 {name=IO39
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/lab_pin.sym} 2590 3650 0 0 {name=p256 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 2590 3570 0 0 {name=p257 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 2590 3590 0 0 {name=p258 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2590 3630 0 0 {name=p259 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 2590 3470 0 0 {name=p260 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 1790 3440 0 0 {name=p261 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1790 3180 0 0 {name=p262 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 1790 3730 0 0 {name=p263 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1790 4020 0 0 {name=p264 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2730 3690 0 0 {name=p265 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1790 3470 0 0 {name=p266 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 1790 3760 0 0 {name=p267 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 2730 3430 0 0 {name=p268 sig_type=std_logic lab=VDD

}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 60 4020 0 0 {name=IO40
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 60 3730 0 0 {name=IO41
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 60 3440 0 0 {name=IO42
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/lab_pin.sym} 320 3220 0 1 {name=p269 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 320 3510 0 1 {name=p270 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 320 3800 0 1 {name=p271 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 320 3300 0 1 {name=p272 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 320 3590 0 1 {name=p273 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 320 3880 0 1 {name=p274 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 320 3400 0 1 {name=p275 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 320 3980 0 1 {name=p276 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 320 3690 0 1 {name=p277 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 320 3570 0 1 {name=p278 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 320 3860 0 1 {name=p279 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 320 3280 0 1 {name=p280 sig_type=std_logic lab=L}
C {/foss/designs/sscs-chipathon-2025/resources/Integration/Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1200 3690 0 1 {name=IO43
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {devices/lab_pin.sym} 940 3650 0 0 {name=p281 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 940 3570 0 0 {name=p282 sig_type=std_logic lab=H}
C {devices/lab_pin.sym} 940 3590 0 0 {name=p283 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 940 3630 0 0 {name=p284 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 940 3470 0 0 {name=p285 sig_type=std_logic lab=L}
C {devices/lab_pin.sym} 140 3440 0 0 {name=p286 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 140 3180 0 0 {name=p287 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 140 3730 0 0 {name=p288 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 140 4020 0 0 {name=p289 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1080 3690 0 0 {name=p290 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 140 3470 0 0 {name=p291 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 140 3760 0 0 {name=p292 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 1080 3430 0 0 {name=p293 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 800 1690 0 1 {name=p294 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 800 1730 0 1 {name=p295 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2390 1690 0 1 {name=p296 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 2390 1730 0 1 {name=p297 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2420 2580 0 1 {name=p298 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 2420 2620 0 1 {name=p299 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 800 2580 0 1 {name=p300 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 800 2620 0 1 {name=p301 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 800 3590 0 1 {name=p302 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 800 3630 0 1 {name=p303 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2450 3590 0 1 {name=p304 sig_type=std_logic lab=VDD

}
C {devices/lab_pin.sym} 2450 3630 0 1 {name=p305 sig_type=std_logic lab=VSS}
